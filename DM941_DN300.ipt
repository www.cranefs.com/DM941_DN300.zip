# Autodesk Inventor part: DM941_DN300
## iProperties
Created: 2011-03
Part Number: DM941_DN300
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
